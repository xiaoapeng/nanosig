## test/zephyr/testcase.yaml
```yaml
tests:
  nanosig.zephyr.platform:
    tags:
      - nanosig
      - platform
    platform_allow:
      - native_sim/native/64
    timeout: 90
```
